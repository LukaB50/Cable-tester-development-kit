# Keil uVision project Cable_tester.uvproj, settings and files
target v1.0. (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: empty_project
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1
  c define: CORE_M4
  c include: ..\lpcopen\lpc_core\lpc_chip\chip_18xx_43xx;..\lpcopen\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\lpcopen\lpc_core\lpc_chip\chip_common;..\lpcopen\CMSIS\CMSIS\Include;.\inc;..\lpc43xx\Drivers\include;..\lpc43xx\Core\Device\NXP\LPC43xx\Include
  asm define: CORE_M4
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./src/: sysinit_m4.c startup_m4.s
  group src
    ./src/: main.c
  group inc
    ./inc/: timers.h config_pin.h
  group lib
    ../lpcopen/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
  group Drivers
    ./src/: timers.c config_pin.c
